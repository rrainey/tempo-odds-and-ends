## boards/Riley_Rainey/tempo_bt/board.yml
```yaml
board:
  name: tempo_bt
  vendor: Riley_Rainey
  socs:
  - name: 'nrf5340'
    variants:
    - name: 'ns'
      cpucluster: 'cpuapp'
```
